# Keil uVision project Mini-Printer.uvprojx, settings and files
target Mini-Printer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Mini-Printer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;                 ../Drivers/STM32F1xx_HAL_Driver/Inc;                 ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                 ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                 ../Drivers/CMSIS/Include;                 ..\User;                 ..\Middle\FreeRtos\include;                 ..\Middle\FreeRtos\portable\RVDS\ARM_CM3;                 ..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middle\FreeRtos\source
    ../Middle/FreeRtos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middle\FreeRtos\portable
    ../Middle/FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../Middle/FreeRtos/portable/MemMang/: heap_4.c
  group User
    ../User/src/: key.c led.c freertos_start.c sys_init.c adc_dection.c ble.c
software components: CMSIS:CORE 4.3.0
